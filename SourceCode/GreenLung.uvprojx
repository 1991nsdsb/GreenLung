# Keil uVision project GreenLung.uvprojx, settings and files
target GreenLung (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: GreenLung_s130_app +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 NRF51422 BOARD_PCA10028 NRF_SD_BLE_API_VERSION=2 S130 SWI_DISABLE0 NRF51 SOFTDEVICE_PRESENT NRF_DFU_SETTINGS_VERSION=1 SWI_DISABLE0
  c include: ..\SourceCode;.\config;..\components;..\components\ble\ble_advertising;..\components\ble\ble_dtm;..\components\ble\ble_racp;..\components\ble\ble_services\ble_ancs_c;..\components\ble\ble_services\ble_ans_c;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_bas_c;..\components\ble\ble_services\ble_cscs;..\components\ble\ble_services\ble_cts_c;..\components\ble\ble_services\ble_dfu;..\components\ble\ble_services\ble_dis;..\components\ble\ble_services\ble_gls;..\components\ble\ble_services\ble_hids;..\components\ble\ble_services\ble_hrs;..\components\ble\ble_services\ble_hrs_c;..\components\ble\ble_services\ble_hts;..\components\ble\ble_services\ble_ias;..\components\ble\ble_services\ble_ias_c;..\components\ble\ble_services\ble_lbs;..\components\ble\ble_services\ble_lbs_c;..\components\ble\ble_services\ble_lls;..\components\ble\ble_services\ble_nus;..\components\ble\ble_services\ble_nus_c;..\components\ble\ble_services\ble_rscs;..\components\ble\ble_services\ble_rscs_c;..\components\ble\ble_services\ble_tps;..\components\ble\common;..\components\ble\nrf_ble_gatt;..\components\ble\nrf_ble_qwr;..\components\ble\peer_manager;..\components\boards;..\components\drivers_nrf\adc;..\components\drivers_nrf\clock;..\components\drivers_nrf\common;..\components\drivers_nrf\comp;..\components\drivers_nrf\delay;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\hal;..\components\drivers_nrf\i2s;..\components\drivers_nrf\lpcomp;..\components\drivers_nrf\pdm;..\components\drivers_nrf\power;..\components\drivers_nrf\ppi;..\components\drivers_nrf\pwm;..\components\drivers_nrf\qdec;..\components\drivers_nrf\rng;..\components\drivers_nrf\rtc;..\components\drivers_nrf\saadc;..\components\drivers_nrf\spi_master;..\components\drivers_nrf\spi_slave;..\components\drivers_nrf\swi;..\components\drivers_nrf\timer;..\components\drivers_nrf\twi_master;..\components\drivers_nrf\twis_slave;..\components\drivers_nrf\uart;..\components\drivers_nrf\usbd;..\components\drivers_nrf\wdt;..\components\libraries\bsp;..\components\libraries\button;..\components\libraries\crc16;..\components\libraries\crc32;..\components\libraries\csense;..\components\libraries\csense_drv;..\components\libraries\experimental_section_vars;..\components\libraries\fds;..\components\libraries\fstorage;..\components\libraries\gpiote;..\components\libraries\hardfault;..\components\libraries\hci;..\components\libraries\led_softblink;..\components\libraries\log;..\components\libraries\log\src;..\components\libraries\low_power_pwm;..\components\libraries\mem_manager;..\components\libraries\pwm;..\components\libraries\queue;..\components\libraries\scheduler;..\components\libraries\sensorsim;..\components\libraries\slip;..\components\libraries\timer;..\components\libraries\twi;..\components\libraries\uart;..\components\libraries\usbd;..\components\libraries\usbd\class\audio;..\components\libraries\usbd\class\cdc;..\components\libraries\usbd\class\cdc\acm;..\components\libraries\usbd\class\hid;..\components\libraries\usbd\class\hid\generic;..\components\libraries\usbd\class\hid\kbd;..\components\libraries\usbd\class\hid\mouse;..\components\libraries\usbd\class\msc;..\components\libraries\usbd\config;..\components\libraries\util;..\components\softdevice\common\softdevice_handler;..\components\softdevice\s130\headers;..\components\softdevice\s130\headers\nrf51;..\components\toolchain;..\external\segger_rtt;..\config;..\components\drivers_ext\mpu6050;..\components\drivers_nrf\twi_master\deprecated;..\components\drivers_nrf\twi_master\deprecated\config;..\components\drivers_ext\bmp180;.\UserCode\source;.\UserCode\include;..\components\drivers_ext\SDP3x;..\components\libraries\bootloader\dfu;..\components\libraries\bootloader\ble_dfu;..\components\drivers_ext\BMA2x2;..\components\drivers_ext\W25X40
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__HEAP_SIZE=0,-DNRF51422,-DBOARD_PCA10028,-DNRF_SD_BLE_API_VERSION=2,-DS130,-DSWI_DISABLE0,-DNRF51,-DSOFTDEVICE_PRESENT
  asm include: ..\SourceCode;.\config;..\components;..\components\ble\ble_advertising;..\components\ble\ble_dtm;..\components\ble\ble_racp;..\components\ble\ble_services\ble_ancs_c;..\components\ble\ble_services\ble_ans_c;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_bas_c;..\components\ble\ble_services\ble_cscs;..\components\ble\ble_services\ble_cts_c;..\components\ble\ble_services\ble_dfu;..\components\ble\ble_services\ble_dis;..\components\ble\ble_services\ble_gls;..\components\ble\ble_services\ble_hids;..\components\ble\ble_services\ble_hrs;..\components\ble\ble_services\ble_hrs_c;..\components\ble\ble_services\ble_hts;..\components\ble\ble_services\ble_ias;..\components\ble\ble_services\ble_ias_c;..\components\ble\ble_services\ble_lbs;..\components\ble\ble_services\ble_lbs_c;..\components\ble\ble_services\ble_lls;..\components\ble\ble_services\ble_nus;..\components\ble\ble_services\ble_nus_c;..\components\ble\ble_services\ble_rscs;..\components\ble\ble_services\ble_rscs_c;..\components\ble\ble_services\ble_tps;..\components\ble\common;..\components\ble\nrf_ble_gatt;..\components\ble\nrf_ble_qwr;..\components\ble\peer_manager;..\components\boards;..\components\drivers_nrf\adc;..\components\drivers_nrf\clock;..\components\drivers_nrf\common;..\components\drivers_nrf\comp;..\components\drivers_nrf\delay;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\hal;..\components\drivers_nrf\i2s;..\components\drivers_nrf\lpcomp;..\components\drivers_nrf\pdm;..\components\drivers_nrf\power;..\components\drivers_nrf\ppi;..\components\drivers_nrf\pwm;..\components\drivers_nrf\qdec;..\components\drivers_nrf\rng;..\components\drivers_nrf\rtc;..\components\drivers_nrf\saadc;..\components\drivers_nrf\spi_master;..\components\drivers_nrf\spi_slave;..\components\drivers_nrf\swi;..\components\drivers_nrf\timer;..\components\drivers_nrf\twi_master;..\components\drivers_nrf\twis_slave;..\components\drivers_nrf\uart;..\components\drivers_nrf\usbd;..\components\drivers_nrf\wdt;..\components\libraries\bsp;..\components\libraries\button;..\components\libraries\crc16;..\components\libraries\crc32;..\components\libraries\csense;..\components\libraries\csense_drv;..\components\libraries\experimental_section_vars;..\components\libraries\fds;..\components\libraries\fstorage;..\components\libraries\gpiote;..\components\libraries\hardfault;..\components\libraries\hci;..\components\libraries\led_softblink;..\components\libraries\log;..\components\libraries\log\src;..\components\libraries\low_power_pwm;..\components\libraries\mem_manager;..\components\libraries\pwm;..\components\libraries\queue;..\components\libraries\scheduler;..\components\libraries\sensorsim;..\components\libraries\slip;..\components\libraries\timer;..\components\libraries\twi;..\components\libraries\uart;..\components\libraries\usbd;..\components\libraries\usbd\class\audio;..\components\libraries\usbd\class\cdc;..\components\libraries\usbd\class\cdc\acm;..\components\libraries\usbd\class\hid;..\components\libraries\usbd\class\hid\generic;..\components\libraries\usbd\class\hid\kbd;..\components\libraries\usbd\class\hid\mouse;..\components\libraries\usbd\class\msc;..\components\libraries\usbd\config;..\components\libraries\util;..\components\softdevice\common\softdevice_handler;..\components\softdevice\s130\headers;..\components\softdevice\s130\headers\nrf51;..\components\toolchain;..\external\segger_rtt;..\config;..\components\drivers_ext\mpu6050;..\components\drivers_nrf\twi_master\deprecated;..\components\drivers_nrf\twi_master\deprecated\config;..\components\drivers_ext\bmp180;.\UserCode\include;.\UserCode\source;..\components\drivers_ext\SDP3x;..\components\libraries\bootloader\dfu;..\components\libraries\bootloader\ble_dfu;..\components\drivers_nrf\ppi;..\components\drivers_ext\BMA2x2
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x1fc00
  memory RVCT9: RAM 0x20001fe8 size 0x2000
  group Application
    ./: main.c
    ./config/: sdk_config.h
    ./UserCode/source/: m_batt_meas.c hal_adc.c
  group Board Definition
    ../components/boards/: boards.c
  group Board Support
    ../components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group nRF_BLE
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../components/ble/ble_advertising/: ble_advertising.c
    ../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../components/ble/ble_services/ble_bas/: ble_bas.c
    ../components/ble/ble_services/ble_dis/: ble_dis.c
    ../components/ble/ble_services/ble_hrs/: ble_hrs.c
    ../components/ble/ble_services/ble_dfu/: ble_dfu.c
  group nRF_Drivers
    ../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../components/drivers_nrf/twi_master/deprecated/: twi_hw_master.c
    ../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../components/drivers_nrf/rtc/: nrf_drv_rtc.c
  group nRF_Libraries
    ../components/libraries/button/: app_button.c
    ../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../components/libraries/timer/: app_timer.c
    ../components/libraries/crc16/: crc16.c
    ../components/libraries/fds/: fds.c
    ../components/libraries/fstorage/: fstorage.c
    ../components/libraries/hardfault/: hardfault_implementation.c
    ../components/libraries/crc32/: crc32.c
    ../components/libraries/scheduler/: app_scheduler.c
    ../components/libraries/sensorsim/: sensorsim.c
    ../components/libraries/pwm/: app_pwm.c
  group nRF_Log
    ../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group SensorsDriver
    ../components/drivers_ext/mpu6050/: mpu6050.c
    ../components/drivers_ext/bmp180/: bmp180.c
    ../components/drivers_ext/SDP3x/: SDP3x.c
    ../components/drivers_ext/BMA2x2/: bma2x2.c
    ../components/drivers_ext/W25X40/: w25x40.c
  group nRF_Bootloader
    ../components/libraries/bootloader/dfu/: nrf_dfu_settings.c
    ./: nrf_dfu_flash_greenlung.c
target flash_s130_nrf51_2.0.1_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: s130_nrf51_2.0.1_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_hrs_pca10028_s130;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x200033b0 size 0x4c50
software components: CMSIS:CORE 5.0.2, CMSIS:CORE 4.3.0, Device:Startup 8.11.1, Device:Startup 8.14.1
